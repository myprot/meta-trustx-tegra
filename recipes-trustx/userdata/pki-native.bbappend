
do_compile_append(){
    ln -s ${TEST_CERT_DIR}/ssig_subca.cert ${TEST_CERT_DIR}/ssig_subca.crt
}
